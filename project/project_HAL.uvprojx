# Keil uVision project project_HAL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\HAL_stm32f103c8t6;..\includes
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group project
    ./: project.c
  group stm32
    ../core/stm32/spi/src/: spi.c
    ../core/stm32/gpio/src/: gpio.c
    ../core/stm32/uart/src/: uart.c
    ../core/stm32/flash/src/: flash.c
  group stm32_application
    ../core/stm32_application/uart/src/: uart_app.c
    ../core/stm32_application/flash/src/: flash_app.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
