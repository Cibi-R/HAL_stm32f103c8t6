# Keil uVision project stm32_HAL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\core\os\FreeRTOS\Source\include;..\core\os\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\app\inc;..\core\drv\inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group project
    ./: project.c
  group demo
    ../app/demo/stm32_drv/flash/src/: flash_app.c
    ../app/demo/stm32_drv/timer/src/: timer_app.c
    ../app/demo/stm32_drv/uart/src/: uart_app.c
    ../app/demo/sys/src/: sys.c
    ../app/demo/FreeRTOS/semaphore/src/: sem.c
    ../app/demo/FreeRTOS/task/src/: task1.c task2.c
    ../app/demo/FreeRTOS/mutex/src/: mutex1.c
    ../app/demo/FreeRTOS/dma/src/: dma1.c dma2.c
    ../app/demo/FreeRTOS/queue/src/: queue1.c
    ../app/demo/FreeRTOS/event_groups/src/: event_group.c
  group drv
    ../core/drv/flash/src/: flash.c
    ../core/drv/gpio/src/: gpio.c
    ../core/drv/spi/src/: spi.c
    ../core/drv/timer/src/: timer.c
    ../core/drv/uart/src/: uart.c
    ../core/drv/clk/src/: clk.c
  group FreeRTOS
    ../core/os/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../core/os/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../core/os/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group coreM3
    ../core/coreM3/src/: coreM3.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
